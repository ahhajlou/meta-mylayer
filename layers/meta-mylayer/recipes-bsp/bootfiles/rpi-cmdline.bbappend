CMDLINE:append = "panic=5"