
#do_deploy:append() {
#    echo "# Enable Virtual Button UART" >>$CONFIG
#    echo "dtoverlay=virtual-keyboard" >>$CONFIG
#}


