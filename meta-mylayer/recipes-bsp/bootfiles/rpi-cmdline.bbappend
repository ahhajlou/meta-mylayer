CMDLINE:remove = "root=/dev/mmcblk0p2"
CMDLINE:remove = "rootfstype=ext4"

CMDLINE:append = " setup=setenv setupargs console=null consoleblank=0 earlycon vt.global_cursor_default=0 quiet"
