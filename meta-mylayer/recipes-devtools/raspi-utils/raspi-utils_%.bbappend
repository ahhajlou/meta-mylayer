#OECMAKE_TARGET_COMPILE:append = " kdtc/all"
#OECMAKE_TARGET_INSTALL:append = " kdtc/install"